options:
  parameters:
    generate_options: no_gui
    id: sparsdr_pluto_900mhz_4band
    output_language: python
  states: {}

blocks:
- name: bins0
  id: variable
  parameters:
    value: 14*0+8*0+50
  states: {}
- name: cr
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq0
  id: variable
  parameters:
    value: 0*2.425e9+0*2.426e9+910290000
  states: {}
- name: freq1
  id: variable
  parameters:
    value: 0*2.405e9+0*2.426e9+908.60e6
  states: {}
- name: freq2
  id: variable
  parameters:
    value: 0*2.450e9+0*2.426e9+916e6
  states: {}
- name: freq3
  id: variable
  parameters:
    value: 923.29e6
  states: {}
- name: freq_c
  id: variable
  parameters:
    value: 0*(freq1 - 14e6) + 0*2.425e9 + freq0
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '23'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bins0*61440000/1024
  states: {}
- name: samp_rate_r3
  id: variable
  parameters:
    value: 2.5*800e3
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass(1,samp_rate,150e3,50e3,firdes.WIN_HAMMING)
  states: {}
- name: taps_r3
  id: variable
  parameters:
    value: firdes.low_pass(1,samp_rate_r3,150e3,50e3,firdes.WIN_HAMMING)
  states: {}
- name: variable_sparsdr_combined_pluto_receiver_0
  id: variable_sparsdr_combined_pluto_receiver
  parameters:
    band_0_bins: bins0
    band_0_frequency: freq1+0*2.426e9
    band_10_bins: '1024'
    band_10_frequency: '0.0'
    band_11_bins: '1024'
    band_11_frequency: '0.0'
    band_12_bins: '1024'
    band_12_frequency: '0.0'
    band_13_bins: '1024'
    band_13_frequency: '0.0'
    band_14_bins: '1024'
    band_14_frequency: '0.0'
    band_15_bins: '1024'
    band_15_frequency: '0.0'
    band_16_bins: '1024'
    band_16_frequency: '0.0'
    band_17_bins: '1024'
    band_17_frequency: '0.0'
    band_18_bins: '1024'
    band_18_frequency: '0.0'
    band_19_bins: '1024'
    band_19_frequency: '0.0'
    band_1_bins: bins0
    band_1_frequency: freq0
    band_20_bins: '1024'
    band_20_frequency: '0.0'
    band_21_bins: '1024'
    band_21_frequency: '0.0'
    band_22_bins: '1024'
    band_22_frequency: '0.0'
    band_23_bins: '1024'
    band_23_frequency: '0.0'
    band_24_bins: '1024'
    band_24_frequency: '0.0'
    band_25_bins: '1024'
    band_25_frequency: '0.0'
    band_26_bins: '1024'
    band_26_frequency: '0.0'
    band_27_bins: '1024'
    band_27_frequency: '0.0'
    band_28_bins: '1024'
    band_28_frequency: '0.0'
    band_29_bins: '1024'
    band_29_frequency: '0.0'
    band_2_bins: bins0
    band_2_frequency: freq2
    band_30_bins: '1024'
    band_30_frequency: '0.0'
    band_31_bins: '1024'
    band_31_frequency: '0.0'
    band_3_bins: bins0
    band_3_frequency: freq3
    band_4_bins: '1024'
    band_4_frequency: '0.0'
    band_5_bins: '1024'
    band_5_frequency: '0.0'
    band_6_bins: '1024'
    band_6_frequency: '0.0'
    band_7_bins: '1024'
    band_7_frequency: '0.0'
    band_8_bins: '1024'
    band_8_frequency: '0.0'
    band_9_bins: '1024'
    band_9_frequency: '0.0'
    band_count: '4'
    bin_spec: 0..1024:204800
    buffer_size: 1024 * 1024
    fft_size: '1024'
    frequency: int(freq_c+0*2412000000)
    gain: '60'
    gain_control_mode: slow_attack
    reconstruct_path: /home/gnuradio/.cargo/bin/sparsdr_reconstruct
    shift_amount: '6'
    skip_config: 'False'
    threshold_file: ''
    threshold_source: Bin specification
    uri: ip:192.168.2.1
    zero_gaps: 'False'
  states: {}
- name: variable_sparsdr_combined_pluto_receiver_0_0
  id: variable_sparsdr_combined_pluto_receiver
  parameters:
    band_0_bins: '64'
    band_0_frequency: freq+0*2.426e9
    band_10_bins: '1024'
    band_10_frequency: '0.0'
    band_11_bins: '1024'
    band_11_frequency: '0.0'
    band_12_bins: '1024'
    band_12_frequency: '0.0'
    band_13_bins: '1024'
    band_13_frequency: '0.0'
    band_14_bins: '1024'
    band_14_frequency: '0.0'
    band_15_bins: '1024'
    band_15_frequency: '0.0'
    band_16_bins: '1024'
    band_16_frequency: '0.0'
    band_17_bins: '1024'
    band_17_frequency: '0.0'
    band_18_bins: '1024'
    band_18_frequency: '0.0'
    band_19_bins: '1024'
    band_19_frequency: '0.0'
    band_1_bins: '1024'
    band_1_frequency: '0.0'
    band_20_bins: '1024'
    band_20_frequency: '0.0'
    band_21_bins: '1024'
    band_21_frequency: '0.0'
    band_22_bins: '1024'
    band_22_frequency: '0.0'
    band_23_bins: '1024'
    band_23_frequency: '0.0'
    band_24_bins: '1024'
    band_24_frequency: '0.0'
    band_25_bins: '1024'
    band_25_frequency: '0.0'
    band_26_bins: '1024'
    band_26_frequency: '0.0'
    band_27_bins: '1024'
    band_27_frequency: '0.0'
    band_28_bins: '1024'
    band_28_frequency: '0.0'
    band_29_bins: '1024'
    band_29_frequency: '0.0'
    band_2_bins: '1024'
    band_2_frequency: '0.0'
    band_30_bins: '1024'
    band_30_frequency: '0.0'
    band_31_bins: '1024'
    band_31_frequency: '0.0'
    band_3_bins: '1024'
    band_3_frequency: '0.0'
    band_4_bins: '1024'
    band_4_frequency: '0.0'
    band_5_bins: '1024'
    band_5_frequency: '0.0'
    band_6_bins: '1024'
    band_6_frequency: '0.0'
    band_7_bins: '1024'
    band_7_frequency: '0.0'
    band_8_bins: '1024'
    band_8_frequency: '0.0'
    band_9_bins: '1024'
    band_9_frequency: '0.0'
    band_count: '1'
    bin_spec: 0..1024:204800
    buffer_size: 1024 * 1024
    fft_size: '1024'
    frequency: int(freq_c+0*2412000000)
    gain: '60'
    gain_control_mode: manual
    reconstruct_path: /home/gnuradio/.cargo/bin/sparsdr_reconstruct
    shift_amount: '6'
    skip_config: 'False'
    threshold_file: ''
    threshold_source: Bin specification
    uri: ip:192.168.2.1
    zero_gaps: 'False'
  states: {state: disabled}
- name: variable_sparsdr_combined_pluto_receiver_1
  id: variable_sparsdr_combined_pluto_receiver
  parameters:
    band_0_bins: '1024'
    band_0_frequency: '0.0'
    band_10_bins: '1024'
    band_10_frequency: '0.0'
    band_11_bins: '1024'
    band_11_frequency: '0.0'
    band_12_bins: '1024'
    band_12_frequency: '0.0'
    band_13_bins: '1024'
    band_13_frequency: '0.0'
    band_14_bins: '1024'
    band_14_frequency: '0.0'
    band_15_bins: '1024'
    band_15_frequency: '0.0'
    band_16_bins: '1024'
    band_16_frequency: '0.0'
    band_17_bins: '1024'
    band_17_frequency: '0.0'
    band_18_bins: '1024'
    band_18_frequency: '0.0'
    band_19_bins: '1024'
    band_19_frequency: '0.0'
    band_1_bins: '1024'
    band_1_frequency: '0.0'
    band_20_bins: '1024'
    band_20_frequency: '0.0'
    band_21_bins: '1024'
    band_21_frequency: '0.0'
    band_22_bins: '1024'
    band_22_frequency: '0.0'
    band_23_bins: '1024'
    band_23_frequency: '0.0'
    band_24_bins: '1024'
    band_24_frequency: '0.0'
    band_25_bins: '1024'
    band_25_frequency: '0.0'
    band_26_bins: '1024'
    band_26_frequency: '0.0'
    band_27_bins: '1024'
    band_27_frequency: '0.0'
    band_28_bins: '1024'
    band_28_frequency: '0.0'
    band_29_bins: '1024'
    band_29_frequency: '0.0'
    band_2_bins: '1024'
    band_2_frequency: '0.0'
    band_30_bins: '1024'
    band_30_frequency: '0.0'
    band_31_bins: '1024'
    band_31_frequency: '0.0'
    band_3_bins: '1024'
    band_3_frequency: '0.0'
    band_4_bins: '1024'
    band_4_frequency: '0.0'
    band_5_bins: '1024'
    band_5_frequency: '0.0'
    band_6_bins: '1024'
    band_6_frequency: '0.0'
    band_7_bins: '1024'
    band_7_frequency: '0.0'
    band_8_bins: '1024'
    band_8_frequency: '0.0'
    band_9_bins: '1024'
    band_9_frequency: '0.0'
    band_count: '1'
    bin_spec: 0..8:1
    buffer_size: 1024 * 1024
    fft_size: '1024'
    frequency: '2412000000'
    gain: '60'
    gain_control_mode: manual
    reconstruct_path: sparsdr_reconstruct
    shift_amount: '6'
    skip_config: 'False'
    threshold_file: ''
    threshold_source: Bin specification
    uri: ip:192.168.2.1
    zero_gaps: 'False'
  states: {state: disabled}
- name: variable_sparsdr_simple_combined_pluto_receiver_0
  id: variable_sparsdr_simple_combined_pluto_receiver
  parameters:
    band_0_bandwidth: 2e6
    band_0_frequency: 2.426e9
    band_10_bandwidth: 2e6
    band_10_frequency: 2.426e9
    band_11_bandwidth: 2e6
    band_11_frequency: 2.426e9
    band_12_bandwidth: 2e6
    band_12_frequency: 2.426e9
    band_13_bandwidth: 2e6
    band_13_frequency: 2.426e9
    band_14_bandwidth: 2e6
    band_14_frequency: 2.426e9
    band_15_bandwidth: 2e6
    band_15_frequency: 2.426e9
    band_16_bandwidth: 2e6
    band_16_frequency: 2.426e9
    band_17_bandwidth: 2e6
    band_17_frequency: 2.426e9
    band_18_bandwidth: 2e6
    band_18_frequency: 2.426e9
    band_19_bandwidth: 2e6
    band_19_frequency: 2.426e9
    band_1_bandwidth: 2e6
    band_1_frequency: 2.426e9
    band_20_bandwidth: 2e6
    band_20_frequency: 2.426e9
    band_21_bandwidth: 2e6
    band_21_frequency: 2.426e9
    band_22_bandwidth: 2e6
    band_22_frequency: 2.426e9
    band_23_bandwidth: 2e6
    band_23_frequency: 2.426e9
    band_24_bandwidth: 2e6
    band_24_frequency: 2.426e9
    band_25_bandwidth: 2e6
    band_25_frequency: 2.426e9
    band_26_bandwidth: 2e6
    band_26_frequency: 2.426e9
    band_27_bandwidth: 2e6
    band_27_frequency: 2.426e9
    band_28_bandwidth: 2e6
    band_28_frequency: 2.426e9
    band_29_bandwidth: 2e6
    band_29_frequency: 2.426e9
    band_2_bandwidth: 2e6
    band_2_frequency: 2.426e9
    band_30_bandwidth: 2e6
    band_30_frequency: 2.426e9
    band_31_bandwidth: 2e6
    band_31_frequency: 2.426e9
    band_3_bandwidth: 2e6
    band_3_frequency: 2.426e9
    band_4_bandwidth: 2e6
    band_4_frequency: 2.426e9
    band_5_bandwidth: 2e6
    band_5_frequency: 2.426e9
    band_6_bandwidth: 2e6
    band_6_frequency: 2.426e9
    band_7_bandwidth: 2e6
    band_7_frequency: 2.426e9
    band_8_bandwidth: 2e6
    band_8_frequency: 2.426e9
    band_9_bandwidth: 2e6
    band_9_frequency: 2.426e9
    band_count: '1'
    buffer_size: 1024 * 1024
    frequency: '2412000000'
    gain: '60'
    gain_control_mode: manual
    reconstruct_path: sparsdr_reconstruct
    shift_amount: '6'
    skip_config: 'False'
    threshold: '1000'
    uri: ip:192.168.2.1
    zero_gaps: 'False'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 2*(samp_rate_r3)/(2*math.pi*20e3/8.0)
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 2*(samp_rate)/(2*math.pi*20e3/8.0)
  states: {}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/test.bin
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52004'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {state: disabled}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52003'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {state: disabled}
- name: blocks_sub_xx_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: int(samp_rate/100000)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: int(samp_rate/40000)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.000225'
    mu: '0.5'
    omega: '1.92'
    omega_relative_limit: '0.0002'
    type: float
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-200e3'
    decim: '1'
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: ieee802_15_4_packet_sink_0_0_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: '10'
  states: {state: disabled}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    taps: "[-0.128616616593872,\t-0.212206590789194,\t-0.180063263231421,\t3.89817183251938e-17\t,0.300105438719035\t,0.636619772367581\t,0.900316316157106,\t1\t,0.900316316157106,\t0.636619772367581,\t0.300105438719035,\t3.89817183251938e-17,\t-0.180063263231421,\t-0.212206590789194,\t-0.128616616593872]"
    type: ccf
  states: {state: disabled}
- name: lora_sdr_hier_rx_0
  id: lora_sdr_hier_rx
  parameters:
    bw: '125000'
    cr: cr
    exit: 'True'
    has_crc: 'True'
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: '125000'
    sf: '7'
  states: {}
- name: lora_sdr_hier_rx_0_0
  id: lora_sdr_hier_rx
  parameters:
    bw: '125000'
    cr: cr
    exit: 'True'
    has_crc: 'True'
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: '125000'
    sf: '7'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2.5*40e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2.5*40e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_r3
    type: fir_filter_fff
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: imput samp_rate=500k
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 64.0 / 1024.0 * 61.44e6
    fc: freq
    fftsize: '64'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '42'
    interp: '25'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: 48*0+24
    interp: 50*0+25
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '1'
    taps: "[-0.128616616593872,\t-0.212206590789194,\t-0.180063263231421,\t3.89817183251938e-17\t,0.300105438719035\t,0.636619772367581\t,0.900316316157106,\t1\t,0.900316316157106,\t0.636619772367581,\t0.300105438719035,\t3.89817183251938e-17,\t-0.180063263231421,\t-0.212206590789194,\t-0.128616616593872]"
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '1'
    taps: "[-0.128616616593872,\t-0.212206590789194,\t-0.180063263231421,\t3.89817183251938e-17\t,0.300105438719035\t,0.636619772367581\t,0.900316316157106,\t1\t,0.900316316157106,\t0.636619772367581,\t0.300105438719035,\t3.89817183251938e-17,\t-0.180063263231421,\t-0.212206590789194,\t-0.128616616593872]"
    type: ccc
  states: {}
- name: single_pole_iir_filter_xx_0_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {state: disabled}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:5559
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:5559
    timeout: '100'
  states: {state: disabled}
- name: zeromq_push_msg_sink_0_0_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:5558
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0_1
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:5560
    timeout: '100'
  states: {}
- name: zwave_packet_sink_0
  id: zwave_packet_sink
  parameters: {}
  states: {}
- name: zwave_packet_sink_0_0
  id: zwave_packet_sink
  parameters: {}
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', low_pass_filter_0, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_float_0, '1', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', lora_sdr_hier_rx_0_0, '0']
- [digital_binary_slicer_fb_0, '0', zwave_packet_sink_0, '0']
- [digital_binary_slicer_fb_0_0, '0', zwave_packet_sink_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [interp_fir_filter_xxx_0, '0', lora_sdr_hier_rx_0, '0']
- [lora_sdr_hier_rx_0, msg, blocks_message_debug_0, print_pdu]
- [lora_sdr_hier_rx_0, msg, zeromq_push_msg_sink_0_0, in]
- [lora_sdr_hier_rx_0, msg, zeromq_push_msg_sink_0_0_0, in]
- [lora_sdr_hier_rx_0_0, msg, blocks_message_debug_0, print_pdu]
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [low_pass_filter_0_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', lora_sdr_hier_rx_0, '0']
- [rational_resampler_xxx_0_0_0, '0', lora_sdr_hier_rx_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', lora_sdr_hier_rx_0, '0']
- [rational_resampler_xxx_0_0_0_0_0, '0', blocks_complex_to_float_0, '0']
- [variable_sparsdr_combined_pluto_receiver_0, '0', blocks_file_sink_0, '0']
- [variable_sparsdr_combined_pluto_receiver_0, '0', blocks_tag_debug_0, '0']
- [variable_sparsdr_combined_pluto_receiver_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [variable_sparsdr_combined_pluto_receiver_0, '0', interp_fir_filter_xxx_0, '0']
- [variable_sparsdr_combined_pluto_receiver_0, '0', qtgui_waterfall_sink_x_0, '0']
- [variable_sparsdr_combined_pluto_receiver_0, '0', rational_resampler_xxx_0_0, '0']
- [variable_sparsdr_combined_pluto_receiver_0, '0', rational_resampler_xxx_0_0_0, '0']
- [variable_sparsdr_combined_pluto_receiver_0, '1', rational_resampler_xxx_0_0_0_0, '0']
- [variable_sparsdr_combined_pluto_receiver_0, '2', analog_quadrature_demod_cf_0, '0']
- [variable_sparsdr_combined_pluto_receiver_0, '3', rational_resampler_xxx_0_0_0_0_0, '0']
- [zwave_packet_sink_0, out, blocks_message_debug_0_0, print_pdu]
- [zwave_packet_sink_0, out, blocks_socket_pdu_0_0, pdus]
- [zwave_packet_sink_0, out, zeromq_push_msg_sink_0, in]
- [zwave_packet_sink_0_0, out, blocks_message_debug_0_0, print_pdu]
- [zwave_packet_sink_0_0, out, blocks_socket_pdu_0, pdus]
- [zwave_packet_sink_0_0, out, blocks_socket_pdu_0_0, pdus]
- [zwave_packet_sink_0_0, out, zeromq_push_msg_sink_0_1, in]

metadata:
  file_format: 1
