options:
  parameters:
    category: '[WiSec2021]'
    generate_options: qt_gui
    id: zigbee_rx
    output_language: python
    title: Zigbee RX
  states: {}

blocks:
- name: Channel
  id: variable
  parameters:
    value: '26'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: 1000000 * (2400 + 5 * (Channel - 10))
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6+0*4e6
  states: {}
- name: samp_rate_in
  id: variable
  parameters:
    value: 10e6
  states: {state: disabled}
- name: zigbee_decim
  id: variable
  parameters:
    value: '5'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/zigbee_pluto.iq
    type: complex
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/gnuradio/sparsdr/gr-sparsdr/test5.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {state: disabled}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.000225'
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.0002'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '5'
    samp_rate: samp_rate_in
    taps: firdes.complex_band_pass(1, samp_rate_in, -samp_rate_in/(2*zigbee_decim), samp_rate_in/(2*zigbee_decim), 1e6)
    type: ccc
  states: {state: disabled}
- name: ieee802_15_4_packet_sink_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: '10'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: 32768*0 + 1024*1024
    frequency: '2425000000'
    gain1: '''hybrid'''
    manual_gain1: '60'
    quadrature: 'False'
    rfdc: 'False'
    samplerate: 2084000*0+4000000
    uri: ip:192.168.2.1
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {state: disabled}
- name: pad_source_0
  id: pad_source
  parameters:
    label: sdr_in
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 64.0 / 1024.0 * 61.44e6
    fc: '2475000000'
    fftsize: '64'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: 3*16
    interp: '25'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.4'
    interp: '2'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_args: '""'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_sub_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_file_source_1, '0', blocks_throttle_0, '0']
- [blocks_socket_pdu_1, pdus, blocks_socket_pdu_0, pdus]
- [blocks_sub_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', ieee802_15_4_packet_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', rational_resampler_xxx_0_0_0_0, '0']
- [ieee802_15_4_packet_sink_0, out, blocks_message_debug_0, print]
- [ieee802_15_4_packet_sink_0, out, blocks_socket_pdu_0, pdus]
- [ieee802_15_4_packet_sink_0, out, pad_sink_0, in]
- [iio_pluto_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [iio_pluto_source_0, '0', blocks_file_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [pad_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_0, '1']
- [uhd_usrp_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']

metadata:
  file_format: 1
