options:
  parameters:
    generate_options: no_gui
    id: zigbee
    output_language: python
    title: Zigbee
  states: {}

blocks:
- name: Channel
  id: variable
  parameters:
    value: '26'
  states: {state: disabled}
- name: Channel
  id: variable_qtgui_range
  parameters:
    label: Channel
    orient: Qt.Horizontal
    rangeType: int
    start: '11'
    step: '1'
    stop: '26'
    value: '11'
    widget: slider
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: 1000000 * (2400 + 5 * (Channel - 10))
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 3.84e6+0*4e6
  states: {}
- name: samp_rate_in
  id: variable
  parameters:
    value: 10e6
  states: {state: disabled}
- name: zigbee_decim
  id: variable
  parameters:
    value: '5'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '250000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '2'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/zig.pcap
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/zigbee_probe
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/zigbee_probe_ota
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/zigbee_pluto_3M84.iq
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gnuradio/zigbee_probe_ota
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/gnuradio/sparsdr/gr-sparsdr/test5.bin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_1_0
  id: blocks_file_source
  parameters:
    file: /home/gnuradio/zigbee_pluto_3M84.iq
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '4'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '4'
    type: complex
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_socket_pdu_0_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {state: disabled}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_1_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: float
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '128'
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[0, sin(pi/4), 1, sin(3*pi/4)]'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '16'
    in_type: byte
    out_type: complex
    symbol_table: '[(1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j)]'
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.000225'
    mu: '0.5'
    omega: '1.92'
    omega_relative_limit: '0.0002'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.basic_block):\n    \"\"\"Convert Zigbee Link Quality Indicator (LQI) (0..255) \n       to RFtap signal quality field (qual) (0.0..1.0)\"\"\"\n\n    def __init__(self,param=None):\n        gr.basic_block.__init__(\n            self,\n            name='LQI to qual',   # will show up in GRC\n            in_sig=[],\n            out_sig=[]\n        )\n        self.message_port_register_in(pmt.intern('in'))\n        self.set_msg_handler(pmt.intern('in'), self.handle_msg)\n        self.message_port_register_out(pmt.intern('out'))\n        self.param = param\n\n    def handle_msg(self, pdu):\n        meta, data = pmt.to_python(pdu)\n        # print(\"meta\")\n        # print(type(meta))\n        # print(\"data\")\n        # print(data)\n        # print((self.param.get_center_freq()))\n        meta['qual'] = meta['lqi'] / 255.0\n        meta['nomfreq'] =  self.param #.get_center_freq()\n        pduout = pmt.cons(pmt.to_pmt(meta), pmt.to_pmt(data))\n        self.message_port_pub(pmt.intern('out'), pduout)\n\n"
    param: freq
  states: {state: disabled}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: 2**16
    pad_front: '0'
    pad_tail: '8'
  states: {}
- name: foo_packet_pad2_0_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: 2**16
    pad_front: '100'
    pad_tail: '100'
  states: {state: disabled}
- name: foo_packet_pad2_1
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    pad_front: '0'
    pad_tail: '0'
  states: {state: disabled}
- name: foo_packet_pad_0
  id: foo_packet_pad
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    pad_front: '1000'
    pad_tail: '1000'
  states: {state: disabled}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'True'
    tech: '195'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '5'
    samp_rate: samp_rate*2.5
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*zigbee_decim), samp_rate/(2*zigbee_decim), 0.2e6)
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '5'
    samp_rate: samp_rate_in
    taps: firdes.complex_band_pass(1, samp_rate_in, -samp_rate_in/(2*zigbee_decim), samp_rate_in/(2*zigbee_decim), 1e6)
    type: ccc
  states: {state: disabled}
- name: ieee802_15_4_access_code_prefixer_0
  id: ieee802_15_4_access_code_prefixer
  parameters:
    pad: '0x00'
    preamble: '0x000000a7'
  states: {}
- name: ieee802_15_4_packet_sink_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: '10'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import sin, pi
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    taps: filter.firdes.low_pass(1,samp_rate,2e6,100e3,filter.firdes.WIN_HAMMING,6.67)
    type: ccc
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate*4
    type: fir_filter_ccf
    width: 100e3
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: lower nipple is sent first
  states: {}
- name: note_1
  id: note
  parameters:
    note: maps chunks of 4 bis directly to qpsk symbols
  states: {}
- name: note_2
  id: note
  parameters:
    note: half sine pulse shape
  states: {}
- name: note_3
  id: note
  parameters:
    note: 4 samples per (chip) symbol
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '40'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf"'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: 3*16*0+25*0+24*0+1
    interp: 25*0+24*0+25*0+1
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.4'
    interp: '2'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    fbw: '0.4'
    interp: '5'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.4'
    interp: '2'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rftap_rftap_encap_0_0
  id: rftap_rftap_encap
  parameters:
    custom_dissector_name: ''
    custom_dlt: '195'
    encapsulation_from: '2'
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    dev_args: '""'
    gain0: '90'
    len_tag_name: packet_len
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    dev_addr: '"serial=3134B8C"'
    dev_args: '""'
    gain0: '90'
    len_tag_name: packet_len
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: 2e6
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_args: '""'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8008'
  states: {state: disabled}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {state: disabled}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5557
    timeout: '100'
    type: byte
  states: {state: disabled}
- name: zeromq_req_msg_source_0
  id: zeromq_req_msg_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_sub_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '1', blocks_delay_0, '0']
- [blocks_delay_0, '0', blocks_tag_gate_0, '0']
- [blocks_file_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_file_source_0, '0', foo_packet_pad_0, '0']
- [blocks_file_source_1, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_file_source_1_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_file_source_1_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_1_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_file_sink_1, '0']
- [blocks_float_to_complex_0, '0', blocks_null_sink_0, '0']
- [blocks_float_to_complex_0, '0', foo_packet_pad2_0_0, '0']
- [blocks_float_to_complex_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_float_to_complex_0, '0', rational_resampler_xxx_0_0_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_null_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_null_source_1, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', zeromq_push_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0_0_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_0, '1']
- [blocks_socket_pdu_1, pdus, blocks_message_debug_0_0, print_pdu]
- [blocks_socket_pdu_1, pdus, ieee802_15_4_access_code_prefixer_0, in]
- [blocks_sub_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_tag_gate_0, '0', blocks_float_to_complex_0, '1']
- [blocks_tagged_stream_multiply_length_0, '0', foo_packet_pad2_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', ieee802_15_4_packet_sink_0, '0']
- [epy_block_0, out, rftap_rftap_encap_0_0, in]
- [foo_packet_pad2_0, '0', blocks_complex_to_float_0, '0']
- [foo_packet_pad2_0_0, '0', blocks_null_sink_0, '0']
- [foo_packet_pad2_0_0, '0', osmosdr_sink_0, '0']
- [foo_packet_pad2_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [foo_packet_pad2_0_0, '0', uhd_usrp_sink_0, '0']
- [foo_packet_pad_0, '0', analog_quadrature_demod_cf_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', rational_resampler_xxx_0_0_0_0, '0']
- [ieee802_15_4_access_code_prefixer_0, out, blocks_pdu_to_tagged_stream_0_0_0, pdus]
- [ieee802_15_4_packet_sink_0, out, blocks_message_debug_0, print_pdu]
- [ieee802_15_4_packet_sink_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [ieee802_15_4_packet_sink_0, out, blocks_socket_pdu_0, pdus]
- [ieee802_15_4_packet_sink_0, out, blocks_socket_pdu_0_0_0, pdus]
- [ieee802_15_4_packet_sink_0, out, epy_block_0, in]
- [ieee802_15_4_packet_sink_0, out, foo_wireshark_connector_0, in]
- [ieee802_15_4_packet_sink_0, out, zeromq_push_msg_sink_0, in]
- [interp_fir_filter_xxx_0, '0', blocks_file_sink_1, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', blocks_file_sink_2, '0']
- [osmosdr_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', blocks_file_sink_3, '0']
- [rational_resampler_xxx_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0_0_0, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [rftap_rftap_encap_0_0, out, blocks_socket_pdu_0, pdus]
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_0, '1']
- [uhd_usrp_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_2, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [zeromq_req_msg_source_0, out, uhd_usrp_source_0, command]

metadata:
  file_format: 1
