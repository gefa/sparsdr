options:
  parameters:
    generate_options: no_gui
    id: sparsdr_pluto_combined_block_900mhz
    output_language: python
  states: {}

blocks:
- name: freq0
  id: variable
  parameters:
    value: 1*2.405e9+0*2.426e9
  states: {}
- name: freq1
  id: variable
  parameters:
    value: 1*2.425e9+0*2.426e9
  states: {}
- name: freq2
  id: variable
  parameters:
    value: 1*2.450e9+0*2.426e9
  states: {}
- name: freq_c
  id: variable
  parameters:
    value: 0*(freq1 - 14e6) + 2.425e9
  states: {}
- name: variable_sparsdr_combined_pluto_receiver_0
  id: variable_sparsdr_combined_pluto_receiver
  parameters:
    band_0_bins: '64'
    band_0_frequency: freq0+0*2.426e9
    band_10_bins: '1024'
    band_10_frequency: '0.0'
    band_11_bins: '1024'
    band_11_frequency: '0.0'
    band_12_bins: '1024'
    band_12_frequency: '0.0'
    band_13_bins: '1024'
    band_13_frequency: '0.0'
    band_14_bins: '1024'
    band_14_frequency: '0.0'
    band_15_bins: '1024'
    band_15_frequency: '0.0'
    band_16_bins: '1024'
    band_16_frequency: '0.0'
    band_17_bins: '1024'
    band_17_frequency: '0.0'
    band_18_bins: '1024'
    band_18_frequency: '0.0'
    band_19_bins: '1024'
    band_19_frequency: '0.0'
    band_1_bins: '64'
    band_1_frequency: freq1
    band_20_bins: '1024'
    band_20_frequency: '0.0'
    band_21_bins: '1024'
    band_21_frequency: '0.0'
    band_22_bins: '1024'
    band_22_frequency: '0.0'
    band_23_bins: '1024'
    band_23_frequency: '0.0'
    band_24_bins: '1024'
    band_24_frequency: '0.0'
    band_25_bins: '1024'
    band_25_frequency: '0.0'
    band_26_bins: '1024'
    band_26_frequency: '0.0'
    band_27_bins: '1024'
    band_27_frequency: '0.0'
    band_28_bins: '1024'
    band_28_frequency: '0.0'
    band_29_bins: '1024'
    band_29_frequency: '0.0'
    band_2_bins: '64'
    band_2_frequency: freq2
    band_30_bins: '1024'
    band_30_frequency: '0.0'
    band_31_bins: '1024'
    band_31_frequency: '0.0'
    band_3_bins: '1024'
    band_3_frequency: '0.0'
    band_4_bins: '1024'
    band_4_frequency: '0.0'
    band_5_bins: '1024'
    band_5_frequency: '0.0'
    band_6_bins: '1024'
    band_6_frequency: '0.0'
    band_7_bins: '1024'
    band_7_frequency: '0.0'
    band_8_bins: '1024'
    band_8_frequency: '0.0'
    band_9_bins: '1024'
    band_9_frequency: '0.0'
    band_count: '3'
    bin_spec: 0..1024:204800
    buffer_size: 1024 * 1024
    fft_size: '1024'
    frequency: int(freq_c+0*2412000000)
    gain: '60'
    gain_control_mode: fast_attack
    reconstruct_path: /home/gnuradio/.cargo/bin/sparsdr_reconstruct
    shift_amount: '6'
    skip_config: 'False'
    threshold_file: ''
    threshold_source: Bin specification
    uri: ip:192.168.2.1
    zero_gaps: 'True'
  states: {}
- name: variable_sparsdr_combined_pluto_receiver_0_0
  id: variable_sparsdr_combined_pluto_receiver
  parameters:
    band_0_bins: '64'
    band_0_frequency: freq+0*2.426e9
    band_10_bins: '1024'
    band_10_frequency: '0.0'
    band_11_bins: '1024'
    band_11_frequency: '0.0'
    band_12_bins: '1024'
    band_12_frequency: '0.0'
    band_13_bins: '1024'
    band_13_frequency: '0.0'
    band_14_bins: '1024'
    band_14_frequency: '0.0'
    band_15_bins: '1024'
    band_15_frequency: '0.0'
    band_16_bins: '1024'
    band_16_frequency: '0.0'
    band_17_bins: '1024'
    band_17_frequency: '0.0'
    band_18_bins: '1024'
    band_18_frequency: '0.0'
    band_19_bins: '1024'
    band_19_frequency: '0.0'
    band_1_bins: '1024'
    band_1_frequency: '0.0'
    band_20_bins: '1024'
    band_20_frequency: '0.0'
    band_21_bins: '1024'
    band_21_frequency: '0.0'
    band_22_bins: '1024'
    band_22_frequency: '0.0'
    band_23_bins: '1024'
    band_23_frequency: '0.0'
    band_24_bins: '1024'
    band_24_frequency: '0.0'
    band_25_bins: '1024'
    band_25_frequency: '0.0'
    band_26_bins: '1024'
    band_26_frequency: '0.0'
    band_27_bins: '1024'
    band_27_frequency: '0.0'
    band_28_bins: '1024'
    band_28_frequency: '0.0'
    band_29_bins: '1024'
    band_29_frequency: '0.0'
    band_2_bins: '1024'
    band_2_frequency: '0.0'
    band_30_bins: '1024'
    band_30_frequency: '0.0'
    band_31_bins: '1024'
    band_31_frequency: '0.0'
    band_3_bins: '1024'
    band_3_frequency: '0.0'
    band_4_bins: '1024'
    band_4_frequency: '0.0'
    band_5_bins: '1024'
    band_5_frequency: '0.0'
    band_6_bins: '1024'
    band_6_frequency: '0.0'
    band_7_bins: '1024'
    band_7_frequency: '0.0'
    band_8_bins: '1024'
    band_8_frequency: '0.0'
    band_9_bins: '1024'
    band_9_frequency: '0.0'
    band_count: '1'
    bin_spec: 0..1024:204800
    buffer_size: 1024 * 1024
    fft_size: '1024'
    frequency: int(freq_c+0*2412000000)
    gain: '60'
    gain_control_mode: manual
    reconstruct_path: /home/gnuradio/.cargo/bin/sparsdr_reconstruct
    shift_amount: '6'
    skip_config: 'False'
    threshold_file: ''
    threshold_source: Bin specification
    uri: ip:192.168.2.1
    zero_gaps: 'False'
  states: {state: disabled}
- name: variable_sparsdr_combined_pluto_receiver_1
  id: variable_sparsdr_combined_pluto_receiver
  parameters:
    band_0_bins: '1024'
    band_0_frequency: '0.0'
    band_10_bins: '1024'
    band_10_frequency: '0.0'
    band_11_bins: '1024'
    band_11_frequency: '0.0'
    band_12_bins: '1024'
    band_12_frequency: '0.0'
    band_13_bins: '1024'
    band_13_frequency: '0.0'
    band_14_bins: '1024'
    band_14_frequency: '0.0'
    band_15_bins: '1024'
    band_15_frequency: '0.0'
    band_16_bins: '1024'
    band_16_frequency: '0.0'
    band_17_bins: '1024'
    band_17_frequency: '0.0'
    band_18_bins: '1024'
    band_18_frequency: '0.0'
    band_19_bins: '1024'
    band_19_frequency: '0.0'
    band_1_bins: '1024'
    band_1_frequency: '0.0'
    band_20_bins: '1024'
    band_20_frequency: '0.0'
    band_21_bins: '1024'
    band_21_frequency: '0.0'
    band_22_bins: '1024'
    band_22_frequency: '0.0'
    band_23_bins: '1024'
    band_23_frequency: '0.0'
    band_24_bins: '1024'
    band_24_frequency: '0.0'
    band_25_bins: '1024'
    band_25_frequency: '0.0'
    band_26_bins: '1024'
    band_26_frequency: '0.0'
    band_27_bins: '1024'
    band_27_frequency: '0.0'
    band_28_bins: '1024'
    band_28_frequency: '0.0'
    band_29_bins: '1024'
    band_29_frequency: '0.0'
    band_2_bins: '1024'
    band_2_frequency: '0.0'
    band_30_bins: '1024'
    band_30_frequency: '0.0'
    band_31_bins: '1024'
    band_31_frequency: '0.0'
    band_3_bins: '1024'
    band_3_frequency: '0.0'
    band_4_bins: '1024'
    band_4_frequency: '0.0'
    band_5_bins: '1024'
    band_5_frequency: '0.0'
    band_6_bins: '1024'
    band_6_frequency: '0.0'
    band_7_bins: '1024'
    band_7_frequency: '0.0'
    band_8_bins: '1024'
    band_8_frequency: '0.0'
    band_9_bins: '1024'
    band_9_frequency: '0.0'
    band_count: '1'
    bin_spec: 0..8:1
    buffer_size: 1024 * 1024
    fft_size: '1024'
    frequency: '2412000000'
    gain: '60'
    gain_control_mode: manual
    reconstruct_path: sparsdr_reconstruct
    shift_amount: '6'
    skip_config: 'False'
    threshold_file: ''
    threshold_source: Bin specification
    uri: ip:192.168.2.1
    zero_gaps: 'False'
  states: {state: disabled}
- name: variable_sparsdr_simple_combined_pluto_receiver_0
  id: variable_sparsdr_simple_combined_pluto_receiver
  parameters:
    band_0_bandwidth: 2e6
    band_0_frequency: 2.426e9
    band_10_bandwidth: 2e6
    band_10_frequency: 2.426e9
    band_11_bandwidth: 2e6
    band_11_frequency: 2.426e9
    band_12_bandwidth: 2e6
    band_12_frequency: 2.426e9
    band_13_bandwidth: 2e6
    band_13_frequency: 2.426e9
    band_14_bandwidth: 2e6
    band_14_frequency: 2.426e9
    band_15_bandwidth: 2e6
    band_15_frequency: 2.426e9
    band_16_bandwidth: 2e6
    band_16_frequency: 2.426e9
    band_17_bandwidth: 2e6
    band_17_frequency: 2.426e9
    band_18_bandwidth: 2e6
    band_18_frequency: 2.426e9
    band_19_bandwidth: 2e6
    band_19_frequency: 2.426e9
    band_1_bandwidth: 2e6
    band_1_frequency: 2.426e9
    band_20_bandwidth: 2e6
    band_20_frequency: 2.426e9
    band_21_bandwidth: 2e6
    band_21_frequency: 2.426e9
    band_22_bandwidth: 2e6
    band_22_frequency: 2.426e9
    band_23_bandwidth: 2e6
    band_23_frequency: 2.426e9
    band_24_bandwidth: 2e6
    band_24_frequency: 2.426e9
    band_25_bandwidth: 2e6
    band_25_frequency: 2.426e9
    band_26_bandwidth: 2e6
    band_26_frequency: 2.426e9
    band_27_bandwidth: 2e6
    band_27_frequency: 2.426e9
    band_28_bandwidth: 2e6
    band_28_frequency: 2.426e9
    band_29_bandwidth: 2e6
    band_29_frequency: 2.426e9
    band_2_bandwidth: 2e6
    band_2_frequency: 2.426e9
    band_30_bandwidth: 2e6
    band_30_frequency: 2.426e9
    band_31_bandwidth: 2e6
    band_31_frequency: 2.426e9
    band_3_bandwidth: 2e6
    band_3_frequency: 2.426e9
    band_4_bandwidth: 2e6
    band_4_frequency: 2.426e9
    band_5_bandwidth: 2e6
    band_5_frequency: 2.426e9
    band_6_bandwidth: 2e6
    band_6_frequency: 2.426e9
    band_7_bandwidth: 2e6
    band_7_frequency: 2.426e9
    band_8_bandwidth: 2e6
    band_8_frequency: 2.426e9
    band_9_bandwidth: 2e6
    band_9_frequency: 2.426e9
    band_count: '1'
    buffer_size: 1024 * 1024
    frequency: '2412000000'
    gain: '60'
    gain_control_mode: manual
    reconstruct_path: sparsdr_reconstruct
    shift_amount: '6'
    skip_config: 'False'
    threshold: '1000'
    uri: ip:192.168.2.1
    zero_gaps: 'False'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0_0_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/test.bin
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0_0_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.000225'
    mu: '0.5'
    omega: '1.92'
    omega_relative_limit: '0.0002'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.000225'
    mu: '0.5'
    omega: '1.92'
    omega_relative_limit: '0.0002'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.000225'
    mu: '0.5'
    omega: '1.92'
    omega_relative_limit: '0.0002'
    type: float
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0_0_1
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.000225'
    mu: '0.5'
    omega: '1.92'
    omega_relative_limit: '0.0002'
    type: float
  states: {}
- name: ieee802_15_4_packet_sink_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: '10'
  states: {}
- name: ieee802_15_4_packet_sink_0_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: '10'
  states: {}
- name: ieee802_15_4_packet_sink_0_0_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: '10'
  states: {state: disabled}
- name: ieee802_15_4_packet_sink_0_0_1
  id: ieee802_15_4_packet_sink
  parameters:
    th: '10'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 64.0 / 1024.0 * 61.44e6
    fc: freq
    fftsize: '64'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0_0_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_sub_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', blocks_sub_xx_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [analog_quadrature_demod_cf_0_0_1, '0', blocks_sub_xx_0_0_1, '0']
- [analog_quadrature_demod_cf_0_0_1, '0', single_pole_iir_filter_xx_0_0_1, '0']
- [blocks_sub_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_sub_xx_0_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [blocks_sub_xx_0_0_1, '0', digital_clock_recovery_mm_xx_0_0_1, '0']
- [digital_clock_recovery_mm_xx_0, '0', ieee802_15_4_packet_sink_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', ieee802_15_4_packet_sink_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_1, '0', ieee802_15_4_packet_sink_0_0_1, '0']
- [ieee802_15_4_packet_sink_0, out, blocks_message_debug_0, print_pdu]
- [ieee802_15_4_packet_sink_0_0, out, blocks_message_debug_0_0, print_pdu]
- [ieee802_15_4_packet_sink_0_0_1, out, blocks_message_debug_0_0_1, print_pdu]
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_0, '1']
- [single_pole_iir_filter_xx_0_0, '0', blocks_sub_xx_0_0, '1']
- [single_pole_iir_filter_xx_0_0_1, '0', blocks_sub_xx_0_0_1, '1']
- [variable_sparsdr_combined_pluto_receiver_0, '0', analog_quadrature_demod_cf_0, '0']
- [variable_sparsdr_combined_pluto_receiver_0, '0', blocks_file_sink_0, '0']
- [variable_sparsdr_combined_pluto_receiver_0, '0', blocks_tag_debug_0, '0']
- [variable_sparsdr_combined_pluto_receiver_0, '0', qtgui_waterfall_sink_x_0, '0']
- [variable_sparsdr_combined_pluto_receiver_0, '1', analog_quadrature_demod_cf_0_0, '0']
- [variable_sparsdr_combined_pluto_receiver_0, '2', analog_quadrature_demod_cf_0_0_1, '0']

metadata:
  file_format: 1
